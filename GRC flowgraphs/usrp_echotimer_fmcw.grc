<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_echotimer_fmcw</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b210</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>5**4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay_samp</value></param>
<param><key>value</key><value>61</value></param>
<param><key>label</key><value>Number delay samples</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res_cw</value></param>
<param><key>value</key><value>samp_rate/samp_cw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res_up</value></param>
<param><key>value</key><value>samp_rate/samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_output_buffer</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meas_duration</value></param>
<param><key>value</key><value>(samp_cw+samp_up+samp_down)/float(samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>int((samp_up+samp_down+samp_cw)*2)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>protect_samp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res_m</value></param>
<param><key>value</key><value>3e8/2/sweep_freq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>55</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_cw</value></param>
<param><key>value</key><value>1250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_down</value></param>
<param><key>value</key><value>samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_up</value></param>
<param><key>value</key><value>1250000/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sweep_freq</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-150</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>55</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_res_m_s</value></param>
<param><key>value</key><value>samp_rate/samp_cw*3e8/2/center_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>1.0/decim_fac</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>samp_cw/decim_fac</value></param>
<param><key>name</key><value>"CW"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>name</key><value>UP</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>name</key><value>DOWN</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>radar_estimator_fmcw</key>
<param><key>id</key><value>radar_estimator_fmcw_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>push_power</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>samp_down</key><value>samp_down/decim_fac</value></param>
<param><key>samp_up</key><value>samp_up/decim_fac</value></param>
<param><key>sweep_freq</key><value>sweep_freq</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0</value></param>
<param><key>axis_y</key><value>0,20</value></param>
<param><key>label</key><value>"TRACKING"</value></param>
<param><key>label_y</key><value>"range"</value></param>
<param><key>range_time</key><value>60</value></param>
<param><key>interval</key><value>100</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_0</value></param>
<param><key>axis_y</key><value>-2,2</value></param>
<param><key>label</key><value>"TRACKING"</value></param>
<param><key>label_y</key><value>"velocity"</value></param>
<param><key>range_time</key><value>60</value></param>
<param><key>interval</key><value>100</value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>freq_cw</key><value>-(sweep_freq)/2</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_cw</key><value>samp_cw</value></param>
<param><key>samp_down</key><value>samp_down</value></param>
<param><key>samp_up</key><value>samp_up</value></param>
<param><key>freq_sweep</key><value>sweep_freq</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>0</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>1</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>2</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
</block>
<block>
<key>radar_tracking_singletarget</key>
<param><key>id</key><value>radar_tracking_singletarget_0</value></param>
<param><key>filter</key><value>"kalman"</value></param>
<param><key>num_particle</key><value>500</value></param>
<param><key>std_range_meas</key><value>1</value></param>
<param><key>std_accel_sys</key><value>0.01</value></param>
<param><key>std_velocity_meas</key><value>v_res_m_s</value></param>
<param><key>threshold_lost</key><value>1</value></param>
<param><key>threshold_track</key><value>0.001</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_cw/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_1</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_up/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_2</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_down/decim_fac</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>num_delay_samps</key><value>int(delay_samp)</value></param>
<param><key>antenna_rx</key><value>'RX2'</value></param>
<param><key>args_rx</key><value></value></param>
<param><key>clock_source_rx</key><value>'internal'</value></param>
<param><key>gain_rx</key><value>rx_gain</value></param>
<param><key>time_source_rx</key><value>'none'</value></param>
<param><key>wait_rx</key><value>wait_to_start</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>antenna_tx</key><value>'TX/RX'</value></param>
<param><key>args_tx</key><value></value></param>
<param><key>gain_tx</key><value>tx_gain</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>b210</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>b210</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fmcw_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fmcw_0</source_block_id><sink_block_id>radar_tracking_singletarget_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in CW</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in UP</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in DOWN</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_tracking_singletarget_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_tracking_singletarget_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>radar_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_1</source_block_id><sink_block_id>radar_find_max_peak_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_2</source_block_id><sink_block_id>radar_find_max_peak_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
